FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Do-not-expect-libnuma-to-be-present.patch \
	   "
